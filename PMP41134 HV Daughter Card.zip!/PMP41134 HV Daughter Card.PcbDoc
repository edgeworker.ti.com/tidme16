# Altium PCB PMP41134 HV Daughter Card.PcbDoc (part 3 of 3)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 2365.13 x 2059.01 mil, 6 copper layers (Top Layer, MidLayer1, MidLayer2, MidLayer3, MidLayer4, Bottom Layer), stack 72.6 mil thick; 59 components, 38 nets, 189 pads, 284 vias.
Unrouted connection lines stored in the file: 15.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
Width [All] p1: maxlimit=100 minlimit=6 preferedwidth=10 substack1={A02F224D-4808-492E-A71F-5F5656FBF0D4} substack2={B838D286-A00B-4EE2-88E1-F79279CC64B4} substack3={0D253197-D122-4D2B-9584-B8C12AA3806F} substack4={88BCB183-C685-456E-B90A-365A53404C2C} substack5={4C8C2325-90D5-40B8-8B6B-4F66D44EFE25} substack6={553D66F5-99EF-40B1-BA7C-73E3B04B176F} substack7={FF0C9878-5A48-402E-B013-8E2EEFCEDCCB} substack8={5BB5B65B-6C7F-4868-A6AE-66DD57ADDCBD} substack9={65866CD6-1929-42AF-BAA8-019D5E6BA212} substack10={590F0BEA-1E04-4904-B9C9-D9D160075BC2} substack11={B2AC4F48-1A5F-44D7-A91B-3BAADFDAAED0} substack12={DD3D4156-A54D-4E1F-B7FF-E5EF72C45496} substack13={7CC4AE65-1EB7-43C1-8FCA-3677EE54F737} substack14={E8C37195-128A-4AA0-B681-9B6788FCEC2F} substack15={92E0C252-34CC-4501-B85F-B111C59C3287} substack16={732F7058-E977-446F-8A06-ECA871B5D75E} substack17={990DA1BC-A1DE-47D8-A675-B5A4E74B5332} checkconnectedcopper=TRUE
14 further rules are at their usual default settings.

## Classes and differential pairs
net class VSW: 18V1 HV_SW1 NetC17_1 NetD4_2 NetD6_1 NetD6_2 NetLabel10 NetR11_2 NetT1_3 NetT1_8 VSSB
net class PGND: 18V2 NetC16_2 NetD1_1 NetD1_2 NetD3_2 NetR9_2 PGND VSSA
net class INGND: 12Vp INGND NetC8_2 NetC9_1 NetD2_2 NetLabel10 NetR1_1 NetR3_1 NetR3_2 NetR16_1
net class HVBUS: HVBUS
net class DGND: 5Vs DGND HV_PWM1H HV_PWM1L NetC5_2 NetC6_2 NetJ1_2 NetJ1_4 NetLabel11 NetLabel12 NetLabel13 NetR6_2 NetR7_1 NetU2_7
component class Header: J1

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C1 "GRM31CR71H475KA12L" 1206_180 -915.94,162 r180 bottom value=4.7uF
C2 "EEE-FK1H100P" SM_RADIAL_D -899,498.12 r180 bottom value=10uF
C3 "GRM188Z71C475KE21D" 0603 519.93,1890 r270 bottom value=4.7uF
C4 "GRM155R71E104KE14D" 0402 467.93,1880 r90 bottom value=0.1uF
C5 "CGA3E2C0G1H330J080AA" FP-CGA3E2C0G1H330J080AA_0603-MFG 101.38,1955 r270 bottom value=33pF
C6 "CGA3E2C0G1H330J080AA" FP-CGA3E2C0G1H330J080AA_0603-MFG -12.88,1873.35 r270 bottom value=33pF
C7 "GRM31CR71H475KA12L" 1206_180 -745.2,872.4 r270 bottom value=4.7uF
C8 "GRM188R72A682KA01D" 0603 -713.71,996.28 r180 bottom value=6800pF
C9 "GRM188R71H223KA01D" 0603 -740,728.62 r0 bottom value=0.022uF
C10 "C1206C223KDRACTU" 1206_190 506.71,605 r90 bottom value=0.022uF
C11 "885012206095" 0603 102.12,1390 r0 bottom value=0.1uF
C12 "CGA5L3X7R1H475K160AE" 1206_190 80,1320 r0 bottom value=4.7uF
C13 "CGA5L3X7R1H475K160AE" 1206_190 376.5,1395 r0 bottom value=4.7uF
C14 "885012206095" 0603 345,1325.99 r0 bottom value=0.1uF
C15 "C1812W104KDRACTU" 1812_254 622.48,605 r90 bottom value=0.1uF
C16 "GRM188R71H102KA01D" 0603 -435.93,1739.21 r0 bottom value=1000pF
C17 "GRM188R71H102KA01D" 0603 -835,1835 r90 top value=1000pF
C18 "TMK325B7226MM-PR" 1210_270 -656.2,1749.21 r270 bottom value=22uF
C19 "TMK325B7226MM-PR" 1210_270 -955,1747.91 r270 bottom value=22uF
C20 "C1812W104KDRACTU" 1812_254 770,605 r90 bottom value=0.1uF
C21 "C1206C223KDRACTU" 1206_190 419.57,605 r90 bottom value=0.022uF
D1 "CUS05S40,H3F" SOD-323 101.69,1455 r180 top value=40V
D2 "BAS16D-E3-08" SOD-123 -884.96,1060 r180 bottom value=100V
D3 "PMEG6010CEH,115" SOD-123 -547.99,1748.28 r270 bottom value=60V
D4 "PMEG6010CEH,115" SOD-123 -843.78,1739.57 r270 bottom value=60V
D5 "MMSZ5248B-7-F" SOD-123 -685,1745 r270 top value=18V
D6 "CUS05S40,H3F" SOD-323 686.24,1355 r90 top value=40V
D7 "MMSZ5248B-7-F" SOD-123 -922.22,1741.5 r270 top value=18V
J1 "GRPB042MWCN-RC" Sullins_GRPB042MWCN 1065,145 r90 top
J2 "PBC02SGBN" Sullins_PxC02SGBN -920,320 r180 top
PGND1 "3621-0-32-15-00-00-08-0" Mill-Max_3621-0-32-xx-00-00-08-0 -440,6 r0 top
R1 "CRCW060349K9FKEA" 0603 -645,891.1 r90 bottom value=49.9k
R2 "CRCW060312K4FKEA" 0603 -644.51,762.91 r90 bottom value=12.4k
R3 "CRCW0603432KFKEA" 0603 -870.79,669.8 r0 bottom value=432k
R4 "RC0603FR-0751RL" 0603 -70,1885 r270 bottom value=51.0
R5 "RC0603FR-0751RL" 0603 46.63,1970 r270 bottom value=51.0
R6 "RC0402JR-070RL" 0402 230,1945 r0 bottom value=0
R7 "CRG0402F4K7" 0402 325,1963.5 r90 bottom value=4.70k
R8 "CRCW060312K1FKEA" 0603 -990,698.35 r270 bottom value=12.1k
R9 "CRCW06035R10JNEA" 0603 123.13,1361.5 r270 top value=5.1
R10 "RC0603FR-071RL" 0603 58.39,1361.5 r270 top value=1.00
R11 "CRCW06035R10JNEA" 0603 790,1315 r0 top value=5.1
R12 "ERJ-2RKF1002X" 0402 99.51,1275.06 r0 top value=10.0k
R13 "RC0603FR-071RL" 0603 790,1380 r0 top value=1.00
R14 "ERJ-2RKF1002X" 0402 797.18,1260 r0 top value=10.0k
R15 "CRCW06036K81FKEA" 0603 -713.71,1060.35 r0 bottom value=6.81k
R16 "CRCW0603174KFKEA" 0603 -889.49,985 r180 bottom value=174k
R17 "CRCW060310R0FKEAHP" 0603 -435.93,1683.58 r0 bottom value=10.0
R18 "CRCW060310R0FKEAHP" 0603 -835,1710 r90 top value=10.0
SW1 "3621-0-32-15-00-00-08-0" Mill-Max_3621-0-32-xx-00-00-08-0 30,6 r0 top
T1 "ZA9704-AL" FP-ZA9704-AL_SMD10-MFG -764.74,1375 r90 bottom
TP1 "3621-0-32-15-00-00-08-0" Mill-Max_3621-0-32-xx-00-00-08-0 180,6 r0 top
TP2 "3621-0-32-15-00-00-08-0" Mill-Max_3621-0-32-xx-00-00-08-0 650,6 r0 top
TP3 "3621-0-32-15-00-00-08-0" Mill-Max_3621-0-32-xx-00-00-08-0 -290,6 r0 top
U1 "LM5180QNGURQ1" NGU0008C -876.54,812.02 r270 bottom
U2 "UCC21551CQDWKRQ1" DWK0014A-MFG 228.62,1671.93 r270 bottom
U3 "IMDQ75R027M1HXUMA1" FP-IMDQ75R027M1HXUMA1_HDSOP22-MFG 596.48,794.17 r270 top
U4 "IMDQ75R027M1HXUMA1" FP-IMDQ75R027M1HXUMA1_HDSOP22-MFG -105,794.17 r270 top
Vbulk+1 "3621-0-32-15-00-00-08-0" Mill-Max_3621-0-32-xx-00-00-08-0 500,6 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52, body extent -0.55,-0.3 0.55,0.3, height 0.6
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69, body extent -0.87,-0.47 0.87,0.47, height 1
1206_180 [mm] "1206_180"
  rect 1.1x1.6 smd: 1(-1.7,0) 2(1.7,0)
  silkscreen extent -0.9,-1 0.9,1, body extent -1.75,-0.95 1.75,0.95, height 1.8
1206_190 [mm] "1206_190"
  rect 1.1x1.6 smd: 1(-1.7,0) 2(1.7,0)
  silkscreen extent -0.9,-1 0.9,1, body extent -1.75,-0.95 1.75,0.95, height 1.9
1210_270 [mm] "1210"
  rect 1.3x2.7 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.32,-1.57 2.32,1.57, body extent -1.7,-1.35 1.7,1.35, height 2.7
1812_254 [mm] "SMD, 2-Leads, Body 4.8x3.4mm"
  rect 1.6x3.4 smd: 1(-2,0) 2(2,0)
  silkscreen extent -0.8,-1.7 0.8,1.7, body extent -2.4,-1.7 2.4,1.7, height 2.54
DWK0014A-MFG [mm]
  rrect17% 1.65x0.6 smd paste+0 mask+0: 1(-4.875,4.445) 2(-4.875,3.175) 3(-4.875,1.905) 4(-4.875,0.635) 5(-4.875,-0.635) 6(-4.875,-1.905) 7(-4.875,-3.175) 8(-4.875,-4.445) 9(4.875,-4.445) 10(4.875,-3.175) 11(4.875,-1.905) 14(4.875,1.905) 15(4.875,3.175) 16(4.875,4.445)
  silkscreen extent -6.37,-5.25 3.5,5.25, body extent -5.16,-5.15 5.16,5.15, height 2.65
FP-CGA3E2C0G1H330J080AA_0603-MFG [mm]
  rrect14% 0.7x0.7 smd paste+0 mask+0: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.95,-0.72 0.95,0.72, body extent -0.8,-0.4 0.8,0.4, height 1.1
FP-IMDQ75R027M1HXUMA1_HDSOP22-MFG [mm]
  rrect13% 2.2x0.8 smd paste+0 mask+0: 1(-9.85,5.7) 2(-9.85,4.56) 3(-9.85,3.42) 4(-9.85,2.28) 5(-9.85,1.14) 6(-9.85,0) 7(-9.85,-1.14) 8(-9.85,-2.28) 9(-9.85,-3.42) 10(-9.85,-4.56) 11(-9.85,-5.7) 12(9.85,-5.7) 13(9.85,-4.56) 14(9.85,-3.42) 15(9.85,-2.28) 16(9.85,-1.14) 17(9.85,0) 18(9.85,1.14) 19(9.85,2.28) 20(9.85,3.42) 21(9.85,4.56) 22(9.85,5.7)
  silkscreen extent -11.62,-7.5 7.7,7.5, body extent -10.48,-7.5 10.48,7.5, height 2.5
FP-ZA9704-AL_SMD10-MFG [mm]
  rrect6% 1.6x1.6 smd paste+0 mask+0: 1(-5.8,4) 2(-5.8,2) 3(-5.8,0) 4(-5.8,-2) 5(-5.8,-4) 6(5.8,-4) 7(5.8,-2) 8(5.8,0) 9(5.8,2) 10(5.8,4)
  silkscreen extent -7.3,-6 6.5,6, body extent -6.5,-6 6.5,6, height 6.5
Mill-Max_3621-0-32-xx-00-00-08-0 [mm] "PCB Pin, 0.04\" DIA, R/A, Edge-Mount"
  rrect50% 3.18x3.18 smd: 1(0,2.388)
  body extent -1.59,-5.06 1.59,3.98, height 1.57
NGU0008C [mm] "SON, 8-Leads, Body 4x4mm, Pitch 0.8mm"
  rrect33% 0.6x0.3 smd: 1(-1.9,1.2) 2(-1.9,0.4) 3(-1.9,-0.4) 4(-1.9,-1.2) 5(1.9,-1.2) 6(1.9,-0.4) 7(1.9,0.4) 8(1.9,1.2)
  rrect8% 1.75x1.31 on Bottom Paste: 9(0,-0.755) 9(0,0.755)
  rrect5% 1.98x3 smd paste-1.5: 9(0,0)
  silkscreen extent -2.15,-2.15 2.15,2.15, body extent -2,-2 2,2, height 0.77
SM_RADIAL_D [mm] "6.3 x 5.8mm:  Panasonic D"
  rect 3.2x1.6 smd: 1(-2.5,0) 2(2.5,0)
  silkscreen extent -3.4,-3.4 3.4,3.4, body extent -3.4,-3.4 3.4,3.4, height 6.1
SOD-123 [mm] "On Semi recommended land pattern"
  rect 0.915x1.22 smd: 1(-1.637,0) 2(1.637,0)
  silkscreen extent -2.74,-1.17 2.03,1.17, body extent -1.93,-0.9 1.93,0.9, height 1.35
SOD-323 [mm] "NXP recommended land pattern"
  rect 0.6x0.6 smd paste-0.05: 1(-1.1,0) 2(1.1,0)
  silkscreen extent -2.06,-0.86 1.53,0.86, body extent -1.3,-0.67 1.3,0.68, height 1.1
Sullins_GRPB042MWCN [mm] "Header, 1.27mm, 4x2, R/A, TH"
  rrect50% 1.05x1.05 hole 0.7: 1(-0.635,1.905)
  round 1.05 hole 0.7: 2(0.635,1.905) 3(-0.635,0.635) 4(0.635,0.635) 5(-0.635,-0.635) 6(0.635,-0.635) 7(-0.635,-1.905) 8(0.635,-1.905)
  body extent -5.28,-2.54 0.84,2.54, height 3.4
Sullins_PxC02SGBN [mm] "Header, 2.54mm, 2x1, R/A, TH"
  rect 1.55x1.55 hole 1.016: 1(-1.27,0)
  round 1.55 hole 1.016: 2(1.27,0)
  silkscreen extent -3,1.77 2.54,4.06, body extent -2.54,-0.32 2.54,12.14, height 3.56

## Part data
C1 C7: library part CMP-0008969-2, "CAP, CERM, 4.7 uF, 50 V, +/- 10%, X7R, 1206", Cap_Case=2220, Manufacturer=MuRata, Supplier Part Number 1=24R6347, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=4.7uF
C2: library part CMP-0011175-2, "CAP, AL, 10 uF, 50 V, +/- 20%, 0.88 ohm, AEC-Q200 Grade 2, SMD", Cap_Case=D, Manufacturer=Panasonic, Supplier Part Number 1=PCE3807CT-ND, Tolerance_%=20%, Value1="0.88 ohm", Value2=50V, ValueDisplayed=10uF
C3: library part CMP-0064936-4, "CAP, CERM, 4.7 uF, 16 V,+/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer=MuRata, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=4.7uF
C4: library part CMP-0006659-2, "CAP, CERM, 0.1 uF, 25 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-10698-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=25V, ValueDisplayed=0.1uF
C5 C6: library part CMP-0095622-1, "Cap Ceramic 33pF 50V C0G 5% Pad SMD 0603 +125°C Automotive T/R", Manufacturer=TDK, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=C0G, Tolerance_%=0.05%, ValueDisplayed=33pF
C8: library part CMP-0007487-4, "CAP, CERM, 6800 pF, 100 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer=MuRata, Supplier Part Number 1=GRM188R72A682KA01D-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=100V, ValueDisplayed=6800pF
C9: library part CMP-0007444-4, "CAP, CERM, 0.022 uF, 50 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer=MuRata, Supplier Part Number 1=490-1517-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=0.022uF
C10 C21: library part CMP-0084048-1, "CAP, CERM, 0.022 µF, 1000 V,+/- 10%, X7R, AEC-Q200 Grade 1, 1206", Cap_Case=1206, Manufacturer=Kemet, TempCo=X7R, Tolerance_%=10%, Value2=1000V, ValueDisplayed=0.022µF
C11 C14: library part CMP-0006837-4, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=0.1uF
C12 C13: library part CMP-0085349-1, "CAP, CERM, 4.7 µF, 50 V,+/- 10%, X7R, AEC-Q200 Grade 1, 1206", Cap_Case=1206, Manufacturer=TDK, TempCo=X7R, Tolerance_%=10%, Value2=50V, ValueDisplayed=4.7µF
C15 C20: library part CMP-0009326-2, "CAP, CERM, 0.1 uF, 1000 V, +/- 10%, X7R, 1812", Cap_Case=1812, Manufacturer=Kemet, Supplier Part Number 1=399-6523-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=1000V, ValueDisplayed=0.1uF
C16 C17: library part CMP-0007432-5, "CAP, CERM, 1000 pF, 50 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer=MuRata, Supplier Part Number 1=490-1494-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=1000pF
C18 C19: library part CMP-0009255-2, "CAP, CERM, 22 uF, 25 V, +/- 10%, X7R, AEC-Q200 Grade 1, 1210", Cap_Case=1210, Manufacturer="Taiyo Yuden", TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=25V, ValueDisplayed=22uF
D1 D6: library part CMP-0028748-2, "Diode, Schottky, 40 V, 0.5 A, SOD-323", Manufacturer=Toshiba, Value1=0.5A, Value2=0.6V
D2: library part CMP-0080761-1, "Diode, Switching, 100 V, 0.25 A, AEC-Q101, SOD-123", Manufacturer=Vishay-Semiconductor, Supplier Part Number 1=BAS16D-E3-08GICT-ND, Value1=0.25A, Value2=1.25V
D3 D4: library part CMP-0028377-2, "Diode, Schottky, 60 V, 1 A, SOD-123F", Manufacturer=Nexperia, Value1=1A, Value2=0.57V
D5 D7: library part CMP-0005755-1, "Diode, Zener, 18 V, 500 mW, SOD-123", Manufacturer="Diodes Inc.", Power_W=500mW, Supplier Part Number 1=MMSZ5248B-FDICT-ND, Value1=0.5W
J1: library part CMP-0086278-1, "Header, 1.27mm, 4x2, Gold, R/A, TH", Current_A=1A, Manufacturer="Sullins Connector Solutions", Voltage_V=500V
J2: library part CMP-0054714-1, "Header, 2.54 mm, 2x1, Gold, R/A, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", Supplier Part Number 1=S1321E-02-ND, Voltage_V=1.8kV
PGND1 SW1 TP1 TP2 TP3 Vbulk+1: library part CMP-0082316-1, Manufacturer=Mill-Max, Supplier Part Number 1=575-3621032150000
R1: library part CMP-0022447-4, "RES, 49.9 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-49.9KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=49k9, ValueDisplayed=49.9k
R2: library part CMP-0022031-4, "RES, 12.4 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-12.4KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=12k4, ValueDisplayed=12.4k
R3: library part CMP-0022420-4, "RES, 432 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-432KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=432k, ValueDisplayed=DNP
R4 R5: library part CMP-0023169-5, "RES, 51.0, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-51.0HRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=51R0, ValueDisplayed=51.0
R6: library part CMP-0027004-2, "RES, 0, 5%, 0.063 W, 0402", Manufacturer="Yageo America", Power_W=63mW, Supplier Part Number 1=311-0.0JRCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=0000, ValueDisplayed=0
R7: library part CMP-0026631-1, "RES, 4.70 k, 1%, 0.063 W, 0402", Manufacturer="TE Connectivity", Power_W=63mW, Supplier Part Number 1=A121542CT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=4k70, ValueDisplayed=4.70k
R8: library part CMP-0022030-4, "RES, 12.1 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-12.1KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=12k1, ValueDisplayed=12.1k
R9 R11: library part CMP-0025834-4, "RES, 5.1, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-5.1GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=5R10, ValueDisplayed=5.1
R10 R13: library part CMP-0022900-4, "RES, 1.00, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-1.00HRCT-ND, TempCo="200 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=1R00, ValueDisplayed=1.00
R12 R14: library part CMP-0026658-1, "RES, 10.0 k, 1%, 0.1 W, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P10.0KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10.0k
R15: library part CMP-0022563-4, "RES, 6.81 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-6.81KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=6k81, ValueDisplayed=6.81k
R16: library part CMP-0022085-4, "RES, 174 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-174KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=174k
R17 R18: library part CMP-0022004-4, "RES, 10.0, 1%, 0.25 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-10.0SCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.25W, Value_Code=10R0, ValueDisplayed=10.0
T1: library part CMP-0086949-1, "FLYBACK TRANSFORMER", Manufacturer=Coilcraft
U1: library part CMP-0078633-2, "70-V PSR Flyback Converter With 100-V, 1.2-A Power Switch and Ultra-Low IQ, NGU0008C (WSON-8)", Alternate Manufacturer="Texas Instruments", Alternate PartNumber=LM5180QNGUTQ1
U2: library part CMP-0001435-2, "Automotive 4-A, 6-A, Reinforced Isolation Dual-Channel Gate Driver", Manufacturer="Texas Instruments", Max Power Dissipation=950mW, Max Supply Voltage=25V, Min Supply Voltage=3V, Operating Temperature Range="-40°C to +150°C"
U3 U4: library part CMP-0123083-1, "N-Channel 750 V 64A (Tj) 273W (Tc) Surface Mount PG-HDSOP-22-1", Digikey Part Number=448-IMDQ75R027M1HXUMA1CT-ND, Input Capacitance At Vds="1668pF @ 500V", Manufacturer=Infineon, Mouser Part Number=726-IMDQ75R027M1HXUM, Operating Temperature Range="-55°C to +175°C", Power_W=273W, Pulse Drain Current=198A, Typ Forward Diode Voltage=3.9V

## Free pads (board coordinates)
  round 60 hole 110.24: 1(-590.55,354.33) 1(669.29,1614.17)

## Via types
v1: diameter 19.68, hole 10, Top Layer to Bottom Layer, tented top, 122 vias
v2: diameter 20, hole 10, Top Layer to Bottom Layer, tented bottom, 116 vias
v3: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 42 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 4 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
5Vs: C3.2 C4.1 J1.7 R6.1 U2.3 U2.8 | length 2935.8
  Bottom Layer w15: R6.1@206.38,1945 202.07,1940.69 184,1940.69 153.62,1910.31 153.62,1818.79 162.41,1810 388.79,1810 400.67,1821.88 U2.8@400.67,1853.5
  Bottom Layer w25: 416.73,1853.5 1081.5,1853.5 1195,1740 1195,137.77 1180.36,123.13 1143.13,123.13 J1.7@1140,120
12Vp: C1.1 C2.1 C7.1 C8.1 J2.1 R1.2 R15.2 T1.1 T1.2 U1.3 | length 1477.8
  MidLayer3 w25: v3@-830,545.34 -830,670 -702.99,797.01 v3(-702.99,934.78)
  Bottom Layer w15: U1.3@-860.79,891.13 -860.79,923.99 -839.78,945 -750.87,945 -741.61,935.74 -703.95,935.74 v3(-702.99,934.78) -682.21,934.78 ; R1.2@-645,922.6 -645,923.58 -656.2,934.78 -682.21,934.78 ; T1.1@-607.26,1146.65 T1.2@-686,1146.65 -682.21,1142.87 R15.2@-682.21,1060.35 C8.1@-682.21,996.28 -682.21,934.78
  Bottom Layer w20: C2.1@-781.06,483.84 -759.57,505.34 C2.1@-749.57,505.34
  Bottom Layer w25: C1.1@-849.02,175 -852.17,175 -858.17,181 -858.17,184.15 -870,195.98 -870,300 -870,402.86 -851.07,421.79 -851.07,479.13 -832.07,498.12 C2.1@-810.37,498.12 ; v3(-829.37,545.34) -829.37,517.12 C2.1@-810.37,498.12 ; C2.1@-800.57,498.12 C2.1@-810.37,498.12
18V1: C13.1 C14.1 C17.2 C19.1 D4.1 D7.1 U2.11 | length 1948.6
  Top Layer w20: D7.1@-922.22,1805.96 -919.28,1808.91 D7.1@-914.6,1808.91 ; v3(-886.28,1808.91) D7.1@-914.6,1808.91 ; C17.2@-837.06,1866.69 -880.57,1866.69 -909.53,1837.73 -909.53,1813.98 D7.1@-914.6,1808.91
  MidLayer4 w20: v3(-886.28,1808.91) -790.19,1905 -425.38,1905 -95.38,1575 192.68,1575 313.58,1454.1 v3(313.58,1357.6)
  Bottom Layer w20: C19.1@-955,1805 -951.09,1808.91 v3(-886.28,1808.91) -848.66,1808.91 D4.1@-843.78,1804.03 ; U2.11@303.62,1480 305.43,1478.19 305.43,1403.22 313.65,1395 313.58,1394.93 v3(313.58,1357.6) 313.58,1326.07 C14.1@313.5,1325.99
18V2: C11.1 C12.1 C16.1 C18.1 D3.1 D5.1 U2.16 | length 1444
  Top Layer w20: v3(-685,1845) D5.1@-685,1809.47 -549.47,1809.47 -105,1365 v3(10,1365)
  Bottom Layer w20: v3(-685,1845) -685,1821.88 -669.41,1806.29 C18.1@-656.2,1806.29 C18.1@-645,1817.5 ; C18.1@-645,1809.52 -551.22,1809.52 D3.1@-547.99,1812.75 ; D3.1@-547.99,1803.68 -541.99,1803.68 -486.22,1747.91 -476.13,1747.91 C16.1@-467.43,1739.21 ; v3(10,1365) 10,1323.07 C12.1@13.07,1320 13.07,1329.84 24.72,1341.5 46.63,1341.5 62.48,1357.34 62.48,1381.85 C11.1@70.63,1390 ; U2.16@53.62,1480 53.62,1406.02 C11.1@69.64,1390
DGND: C3.1 C4.2 C5.1 C6.1 J1.1 J1.3 J1.5 R7.2 U2.4 | length 225.4
  Bottom Layer w20: C6.1@-12.88,1900.91 v3(-12.88,1928.5) ; C5.1@101.38,1982.56 v3(101.38,2007.49) ; U2.4@202.93,1864.55 U2.4@203.62,1863.86 v3(203.62,1910.31) ; R7.2@325,1987.13 326.57,1988.7 v3(353.62,1988.7) ; C4.2@468.73,1904.43 C4.2@467.93,1903.62 467.93,1907.56 469.74,1909.37 473.68,1909.37 481.12,1916.81 512.03,1916.81 520.73,1925.51 C3.1@520.73,1926.5 ; v3(519.12,1951.02) 519.12,1922.3 C3.1@519.93,1921.5
HV_PWM1H: J1.8 R4.1 | length 3104.8
  MidLayer3 w25: v3(-70,1950.16) -70,1990 -17.5,2042.5 1032.5,2042.5 1140,1935 J1.8@1140,180
  Bottom Layer w25: R4.1@-70,1916.5 v3(-70,1950.16)
HV_PWM1L: J1.6 R5.1 | length 2811
  MidLayer3 w25: v3(13.07,2001.5) 144.57,1870 1015,1870 1090,1795 J1.6@1090,180
  Bottom Layer w25: v3(13.07,2001.5) R5.1@46.63,2001.5
HV_SW1: SW1.1 TP1.1 U3.3 U3.4 U3.5 U3.6 U3.7 U3.8 U3.9 U3.10 U3.11 U4.12 U4.13 U4.14 U4.15 U4.16 U4.17 U4.18 U4.19 U4.20 U4.21 U4.22
  other v2: -21.28,65.54 4.72,65.54 30.72,65.54 56.72,65.54 82.72,65.54 108.72,65.54 134.72,65.54 160.72,65.54 186.72,65.54 212.72,65.54 -20.47,93.14 5.53,93.14 31.53,93.14 57.53,93.14 83.53,93.14 109.53,93.14 135.53,93.14 161.53,93.14 187.53,93.14 213.53,93.14 -21.28,124.03 4.72,124.03 30.72,124.03 56.72,124.03 82.72,124.03 108.72,124.03 134.72,124.03 160.72,124.03 186.72,124.03 212.72,124.03 7.49,471.7 33.14,471.7 58.8,471.7 84.45,471.7 110.11,471.7 135.76,471.7 161.41,471.7 187.07,471.7 8.3,499.31 33.95,499.31 59.6,499.31 85.26,499.31 110.91,499.31 136.56,499.31 162.22,499.31 213.53,499.31 364.73,1081.89 390.73,1081.89 416.73,1081.89 442.73,1081.89 468.73,1081.89 494.73,1081.89 520.73,1081.89 546.73,1081.89 572.73,1081.89 598.73,1081.89 545.93,1112.78 571.93,1112.78 597.93,1112.78
  other v3: 212.72,471.7 187.87,499.31 7.49,530.2 33.14,530.2 58.8,530.2 84.45,530.2 110.11,530.2 135.76,530.2 161.41,530.2 187.07,530.2 212.72,530.2 363.93,1112.78 389.93,1112.78 415.93,1112.78 441.93,1112.78 467.93,1112.78 493.93,1112.78 519.93,1112.78
HVBUS: C10.1 C15.1 C20.1 C21.1 TP2.1 U3.12 U3.13 U3.14 U3.15 U3.16 U3.17 U3.18 U3.19 U3.20 U3.21 U3.22 Vbulk+1.1
  other v1: 489.31,194.97 514.31,194.97 539.31,194.97 564.31,194.97 589.31,194.97 614.31,194.97 639.31,194.97 664.31,194.97 689.31,194.97 714.31,194.97 501.81,219.97 526.81,219.97 551.81,219.97 576.81,219.97 601.81,219.97 626.81,219.97 651.81,219.97 676.81,219.97 701.81,219.97 489.31,244.97 514.31,244.97 539.31,244.97 564.31,244.97 589.31,244.97 614.31,244.97 639.31,244.97 664.31,244.97 689.31,244.97 714.31,244.97 476.81,269.97 501.81,269.97 526.81,269.97 551.81,269.97 576.81,269.97 601.81,269.97 626.81,269.97 651.81,269.97 676.81,269.97 701.81,269.97 464.31,294.97 489.31,294.97 514.31,294.97 539.31,294.97 564.31,294.97 589.31,294.97 614.31,294.97 639.31,294.97 664.31,294.97 689.31,294.97 714.31,294.97 476.81,319.97 501.81,319.97 526.81,319.97 551.81,319.97 576.81,319.97 601.81,319.97 626.81,319.97 651.81,319.97 676.81,319.97 701.81,319.97
INGND: C1.2 C2.2 C7.2 C9.2 J2.2 R2.1 R8.1 U1.8 U1.9@-876.54,812.02 | length 589.3
  Bottom Layer w15: U1.9@-909.04,779.51 -877.17,811.38 U1.9@-870.65,811.38 ; U1.9@-819.51,792.83 -725.37,792.83 -717.15,792.83 -702.99,778.68 -702.99,728.62 C9.2@-701.52,730.1 ; C9.2@-706.15,729.94 -645.98,729.94 R2.1@-644.51,731.42
  Bottom Layer w20: -997.94,277.78 C2.2@-997.94,467.67 ; -989.15,277.78 -998.06,268.88 -998.06,204.83 C1.2@-973.86,180.63 ; C2.2@-946.42,505.34 C2.2@-946.3,505.22
  other v4: -876.54,782.88 -925.75,812.02 -827.33,812.02 -876.54,841.15
NetC5_2: C5.2 R5.2 U2.2 | length 138.1
  Bottom Layer w15: R5.2@46.63,1938.5 57.7,1927.44 C5.2@101.38,1927.44 102.5,1926.32 102.5,1864.98 U2.2@103.62,1863.86
  Bottom Layer w20: R5.2@46.63,1938.5 46.63,1937.52 55.33,1928.82 R5.2@56.32,1928.82
NetC6_2: C6.2 R4.2 U2.1 | length 142.4
  Bottom Layer w15: R4.2@-70,1853.5 -62.28,1845.79 49.31,1845.79 53.62,1850.1 U2.1@53.62,1863.86
NetC8_2: C8.2 D2.1 R15.1 | length 139.5
  Bottom Layer w15: D2.1@-820.49,1060 -820.14,1060.35 R15.1@-745.2,1060.35 C8.2@-745.2,996.28
NetC9_1: C9.1 U1.5 | length 59.5
  Bottom Layer w15: U1.5@-827.7,736.58 -779.45,736.58 C9.1@-771.5,728.62
NetC16_2: C16.2 R17.2 | length 55.6
  Bottom Layer w20: R17.2@-404.43,1683.58 C16.2@-404.43,1739.21
NetC17_1: C17.1 R18.2 | length 62
  Top Layer w20: R18.2@-835,1741.5 C17.1@-835,1803.5
NetD1_1: D1.1 R9.1 U2.15 | length 171.5
  Top Layer w20: v3(103.62,1440) 116.81,1453.19 143.19,1453.19 D1.1@145,1455 145,1414.86 132.82,1402.68 131.83,1402.68 123.13,1393.98 R9.1@123.13,1392.99 R9.1@114.43,1401.69
  Bottom Layer w20: v3(103.62,1440) U2.15@103.62,1480
NetD1_2: D1.2 R10.1 | length 59.8
  Top Layer w20: R10.1@55.14,1396.5 58.39,1399.74 D1.2@58.39,1455
NetD2_2: D2.2 R16.2 T1.4 T1.5 U1.1 | length 359.2
  Bottom Layer w15: U1.1@-923.94,891.13 -923.94,982.05 R16.2@-920.98,985 -920.98,1026.2 -938.27,1043.48 -938.92,1043.48 -949.43,1054 D2.2@-949.43,1060 -949.43,1066 -938.92,1076.52 -938.36,1076.52 -922.22,1092.66 T1.5@-922.22,1146.65 T1.4@-843.48,1146.65
NetD3_2: D3.2 R17.1 T1.10 | length 172.2
  Bottom Layer w20: T1.10@-607.68,1603.77 T1.10@-607.26,1603.35 -557.48,1653.13 -557.48,1675.8 -549.47,1683.81 D3.2@-547.99,1683.81 ; D3.2@-533.15,1683.58 R17.1@-467.43,1683.58
NetD4_2: D4.2 R18.1 T1.7 | length 110.1
  Top Layer w20: v3(-840,1645) -840,1673.5 R18.1@-835,1678.5
  Bottom Layer w20: D4.2@-843.63,1674.95 -840,1671.32 v3(-840,1645) -840,1606.83 T1.7@-843.48,1603.35
NetD6_1: D6.1 R11.1 U2.10 | length 495.7
  Top Layer w20: v3(367.56,1432.4) 488.27,1311.69 D6.1@686.24,1311.69 755.2,1311.69 R11.1@758.5,1315
  Bottom Layer w20: U2.10@353.62,1480 355.43,1478.19 355.43,1444.53 v3(367.56,1432.4)
NetD6_2: D6.2 R13.1 | length 79.8
  Top Layer w20: D6.2@686.24,1398.31 739.21,1398.31 757.52,1380 R13.1@758.5,1380
NetLabel10: T1.3
NetLabel11: U2.7
NetLabel12: J1.2
NetLabel13: J1.4
NetR1_1: R1.1 R2.2 U1.4 | length 255.2
  Bottom Layer w15: U1.4@-823.81,886.18 -798.43,886.18 -781.69,869.45 -654.84,869.45 -644.75,859.36 -644.75,794.66 R2.2@-644.51,794.41
NetR3_1: R3.1 R8.2 U1.7 | length 151.7
  Bottom Layer w10: R3.1@-892.29,674.71 U1.7@-892.29,732.9
  Bottom Layer w15: R8.2@-997.99,657.85 R8.2@-990,665.85 ; -970.44,665 -902,665 R3.1@-892.29,674.71
NetR3_2: R3.2 U1.6 | length 76.9
  Bottom Layer w10: U1.6@-860.79,737.21 -860.79,690.32 -840.28,669.8 R3.2@-839.29,669.8
NetR6_2: R6.2 U2.5 | length 73.7
  Bottom Layer w15: U2.5@253.62,1863.86 R6.2@253.62,1937.52
NetR7_1: R7.1 U2.6 | length 84.9
  Bottom Layer w15: U2.6@303.62,1863.86 306.5,1866.74 306.5,1905.91 320.69,1920.1 320.69,1935.57 R7.1@325,1939.88
NetR9_2: R9.2 R10.2 R12.2 U4.1 | length 221.1
  Top Layer w20: R10.2@55.14,1333.5 123.13,1333.5 R12.2@123.13,1275.06 123.13,1185.69 U4.1@119.41,1181.97
NetR11_2: R11.2 R13.2 R14.2 U3.1 | length 200.4
  Top Layer w20: U3.1@820.89,1181.97 821.19,1182.27 821.19,1379.69 R13.2@821.5,1380 ; R11.2@821.32,1311.81 R11.2@822.8,1310.33
NetR16_1: R16.1 U1.2 | length 113
  Bottom Layer w15: U1.2@-892.29,886.82 -892.29,940.71 -870.18,962.82 -870.18,973.8 -858.98,985 R16.1@-857.99,985
PGND: C10.2 C15.2 C20.2 C21.2 PGND1.1 TP3.1 U4.3 U4.4 U4.5 U4.6 U4.7 U4.8 U4.9 U4.10 U4.11
  other v1: -362.88,1019.97 -337.88,1019.97 -312.88,1019.97 -287.88,1019.97 -262.88,1019.97 -237.88,1019.97 -212.88,1019.97 -187.88,1019.97 -162.88,1019.97 -137.88,1019.97 -112.88,1019.97 -87.88,1019.97 -62.88,1019.97 -37.88,1019.97 -12.88,1019.97 12.12,1019.97 -350.38,1044.97 -325.38,1044.97 -300.38,1044.97 -275.38,1044.97 -250.38,1044.97 -225.38,1044.97 -200.38,1044.97 -175.38,1044.97 -150.38,1044.97 -125.38,1044.97 -100.38,1044.97 -75.38,1044.97 -50.38,1044.97 -25.38,1044.97 -0.38,1044.97 -362.88,1069.97 -337.88,1069.97 -312.88,1069.97 -287.88,1069.97 -262.88,1069.97 -237.88,1069.97 -212.88,1069.97 -187.88,1069.97 -162.88,1069.97 -137.88,1069.97 -112.88,1069.97 -87.88,1069.97 -62.88,1069.97 -37.88,1069.97 -12.88,1069.97 12.12,1069.97 -350.38,1094.97 -325.38,1094.97 -300.38,1094.97 -275.38,1094.97 -250.38,1094.97 -225.38,1094.97 -200.38,1094.97 -175.38,1094.97 -150.38,1094.97 -125.38,1094.97 -100.38,1094.97 -75.38,1094.97 -50.38,1094.97 -25.38,1094.97 -0.38,1094.97
  other v2: -468.28,70.5 -442.28,70.5 -416.28,70.5 -390.28,70.5 -364.28,70.5 -338.28,70.5 -312.28,70.5 -286.28,70.5 -260.28,70.5 -234.28,70.5 -467.47,98.11 -441.47,98.11 -415.47,98.11 -389.47,98.11 -363.47,98.11 -337.47,98.11 -311.47,98.11 -285.47,98.11 -259.47,98.11 -233.47,98.11 -468.28,129 -442.28,129 -416.28,129 -390.28,129 -364.28,129 -338.28,129 -312.28,129 -286.28,129 -260.28,129 -234.28,129 601.19,762.12 627.19,762.12 653.19,762.12 679.19,762.12 705.19,762.12 731.19,762.12 757.19,762.12 783.19,762.12 809.19,762.12 602,789.72 628,789.72 654,789.72 680,789.72 706,789.72 732,789.72 758,789.72 784,789.72 810,789.72 601.19,820.61 627.19,820.61 653.19,820.61 679.19,820.61 705.19,820.61 731.19,820.61 757.19,820.61 783.19,820.61 809.19,820.61
VSSA: C11.2 C12.2 C18.2 D5.2 R12.1 T1.9 U2.14 U4.2 | length 661.5
  Top Layer w20: U4.2@74.53,1181.97 75.21,1182.65 75.21,1274.38 R12.1@75.89,1275.06
  Top Layer w25: v3(-686,1730) -686,1681.53 D5.2@-685,1680.53
  Bottom Layer w20: v3(75,1250) 110,1250 135.68,1275.68 135.68,1308.75 C12.2@146.93,1320 ; C11.2@133.62,1390 C11.2@134.61,1390 ; U2.14@153.62,1480 153.62,1409.02 C11.2@134.61,1390 ; v3(175.58,1323.07) 150,1323.07 C12.2@146.93,1320 ; C11.2@134.61,1390 140.94,1383.67 140.94,1325.99 C12.2@146.93,1320
  Bottom Layer w25: T1.9@-686,1603.35 -685,1604.35 -685,1679.03 C18.2@-671.91,1692.12 ; v3(-686,1730) -686,1705.21 -672.91,1692.12 C18.2@-671.91,1692.12 ; v3(-653,1730) -653,1695.32 C18.2@-656.2,1692.12 C18.2@-671.91,1692.12
VSSB: C13.2 C14.2 C19.2 D7.2 R14.1 T1.6 U2.9 U3.2 | length 927.9
  Top Layer w20: v3(-922.22,1645) D7.2@-922.22,1677.03 ; v3(743.99,1260) R14.1@773.56,1260
  Top Layer w25: R14.1@773.56,1260 774.09,1260 774.78,1259.31 774.78,1183.19 U3.2@776,1181.97
  Bottom Layer w20: v3(-1020,1690.83) C19.2@-955,1690.83 -937.81,1690.83 -922.22,1675.24 v3(-922.22,1645) T1.6@-922.22,1603.35 ; C14.2@376.5,1325.99 377.48,1325.01 v3(377.48,1295) ; C14.2@386.18,1334.69 386.18,1356.18 406.42,1376.42 431.77,1376.42 443.43,1388.08 C13.2@443.43,1395 ; U2.9@403.62,1480 403.62,1459.33 431.77,1431.18 431.77,1406.65 C13.2@443.43,1395 ; v3(743.99,1260) 692.29,1311.69 488.27,1311.69 451.98,1347.98 451.98,1386.44 C13.2@443.43,1395
pads on no net: T1.8 U1.9@-846.82,812.02 U1.9@-906.27,812.02

## Polygon pours and split planes (outlines as drawn)
HV_SW1 on Top Layer "HV_SW1_L01_P004" (solid, remove dead copper, pour order 4): -365,477.5 -365,340 -345,320 -70,320 -50,300 -50,25.01 -33.49,8.5 244.81,8.5 251.06,14.75 251.06,318.65 97.4,500 -342.5,500
INGND on Top Layer "INGND_L01_P033" (solid, remove dead copper, pour order 33): -1100,1160 -1080,1180 -572.85,1180 -555,1162.15 -555,728.75 -795,488.75 -795,19.75 -806.25,8.5 -1088.75,8.5 -1100,19.75
PGND on Top Layer "PGND_L01_P013" (solid, remove dead copper, pour order 13): -505,144.5 -474.5,175 -218.38,175 -207.5,164.12 -207.5,10.35 -211.86,5.99 -487.49,5.99 -505,23.5
PGND on Top Layer "PGND_L01_P010" (solid, remove dead copper, pour order 10): -405,1205 -382.97,1227.03 43.84,1227.03 45.64,1225.23 45.64,1023.8 18.12,996.28 -383.78,996.28 -405,1017.5
HV_SW1 on Top Layer "HV_SW1_L01_P005" (solid, remove dead copper, pour order 5): 740,1235 747.97,1227.03 747.97,1140 251.06,618.86 251.06,291.61 -10.83,291.61 -10.83,821.14 361.99,1235
HV_SW1 on Top Layer "HV_SW1_L01_P006" (solid, remove dead copper, pour order 6): 10,719.36 -3.59,715.92 -209.32,425.57 -173.75,390 95.43,390 95.43,631.97 14.84,712.56
HVBUS on Top Layer "HVBUS_L01_P001" (solid, remove dead copper, pour order 1): 367.56,560 845,560 860,545 860,291.61 724.62,156.23 724.62,13.62 717,6 447.5,6 435,18.5 435,260.56 350,360 350,542.44
12Vp on Bottom Layer "12VP_L06_P025" (solid, remove dead copper, pour order 25): -775,960.53 -717.15,960.53 -702.99,974.68 -702.99,1097.99 -717.15,1112.15 -717.15,1177.85 -713.03,1181.97 -576.97,1181.97 -575,1180 -575,1105 -620,1060 -620,905 -627.01,897.99 -678.99,897.99 -697.69,916.69 -775,916.69
INGND on Bottom Layer "INGND_L06_P024" (solid, remove dead copper, pour order 24): -1081.75,16.75 -1100,35 -1100,820.64 -1070.64,850 -805,850 -785,830 -694.86,830 -682.21,817.36 -682.21,757.17 -682.18,757.17 -675.01,750 -620,750 -615,745 -615,700 -620,695 -725,695 -730,700 -730,770 -892.97,770 -953.05,709.92 -1006.97,709.92 -1020,696.89 -1020,614.34 -935,529.34 -935,28.68 -946.93,16.75 -978.43,16.75
PGND on Bottom Layer "PGND_L06_P012" (solid, remove dead copper, pour order 12): -405,792.83 -405,242.11 -505,142.11 -505,23.5 -487.5,6 -211.85,6 -207.39,10.46 -207.39,484.4 3.2,695 -20,718.2 -20,789.72 -395.83,789.72 -400.28,794.17
PGND on Bottom Layer "PGND_L06_P009" (solid, remove dead copper, pour order 9): -405,1205 -382.97,1227.03 43.84,1227.03 55.14,1215.73 55.14,1030.32 185.45,900 820,900 860,860 860,665 845,650 -289.65,650 -405,765.35
HVBUS on Bottom Layer "HVBUS_L06_P007" (solid, remove dead copper, pour order 7): 350,542.44 367.56,560 845,560 860,545 860,291.61 724.62,156.23 724.62,13.62 717,6 447.5,6 435,18.5 435,260.56 350,360 350,542.44 367.56,560
PGND on MidLayer1 "PGND_L02_P014" (solid, remove dead copper, pour order 14): -405,1205 -382.97,1227.03 31.81,1227.03 43.84,1215 43.84,1059.24 203.07,900 820,900 853.27,866.73 853.27,658.71 845,650.44 -32.66,650.44 -207.5,475.59 -207.5,10.35 -211.85,6 -487.5,6 -505,23.5 -505,143.3 -405,243.3
VSSA on MidLayer1 "VSSA_L02_P035" (solid, remove dead copper, pour order 35): -718.21,1569.29 -736.35,1587.42 -736.35,1853.65 -725,1865 -505.38,1865 -175.38,1535 176.12,1535 195.49,1515.63 195.49,1140.21 185.59,1130.31 66.39,1130.31 55,1141.7 55,1235 -50,1340 -200,1340 -429.29,1569.29
DGND on MidLayer1 "DGND_L02_P023" (solid, remove dead copper, pour order 23): -130,2050 -115,2065 1110,2065 1230.94,1944.06 1230.94,21.94 1215,6 965,6 950,21 950,1760 920,1790 -117.88,1790 -130,1802.12
INGND on MidLayer4 "INGND_L05_P026" (solid, remove dead copper, pour order 26): -1100,1160 -1080,1180 -572.85,1180 -555,1162.15 -555,730 -795,490 -795,19.75 -806.25,8.5 -1085,8.5 -1100,23.5
DGND on MidLayer4 "DGND_L05_P020" (solid, remove dead copper, pour order 20): -130,2050 -115,2065 1110,2065 1230.94,1944.06 1230.94,21.94 1215,6 965,6 950,21 950,1758.59 918.59,1790 -117.88,1790 -130,1802.12
HV_SW1 on MidLayer4 "HV_SW1_L05_P015" (solid, remove dead copper, pour order 15): 370,1235 729.14,1235 743.99,1220.16 743.99,1137.09 251.06,616.6 251.06,16.06 243.5,8.5 -34.37,8.5 -50.38,24.51 -50.38,780.64
INGND on MidLayer2 "INGND_L03_P027" (solid, remove dead copper, pour order 27): -1100,1160 -1080,1180 -572.85,1180 -555,1162.15 -555,730 -795,490 -795,19.75 -806.25,8.5 -1085,8.5 -1100,23.5
DGND on MidLayer2 "DGND_L03_P021" (solid, remove dead copper, pour order 21): -130,2047.88 -112.88,2065 1110,2065 1230.94,1944.06 1230.94,21.94 1215,6 965,6 950,21 950,1758.59 918.59,1790 -117.88,1790 -130,1802.12
PGND on MidLayer2 "PGND_L03_P017" (solid, remove dead copper, pour order 17): -405,1205 -382.97,1227.03 48.59,1227.03 55.14,1220.48 55.14,1040.14 55,1040 195,900 820,900 853.27,866.73 853.27,658.71 844.56,650 -33.09,650 -207.5,475.59 -207.5,10.35 -211.85,6 -487.5,6 -505,23.5 -505,142.11 -405,242.11
VSSB on MidLayer3 "VSSB_L04_P034" (solid, remove dead copper, pour order 34): -1060,1560 -1078.57,1578.57 -1078.57,1960 -1037.08,2001.5 -426.5,2001.5 -80,1655 315,1655 545,1425 865,1425 880,1410 880,1135.31 869.21,1124.51 764.76,1124.51 747.97,1141.3 747.97,1222.03 700,1270 305,1270 270,1305 270,1475 205,1540 -165,1540 -505,1880 -759.33,1880 -800,1839.33 -800,1580 -820,1560
INGND on MidLayer3 "INGND_L04_P028" (solid, remove dead copper, pour order 28): -1100,1160 -1078.57,1181.43 -574.28,1181.43 -555,1162.15 -555,728.75 -795,488.75 -795,22.43 -810.18,7.25 -811.43,8.5 -1088.75,8.5 -1100,19.75
HVBUS on MidLayer3 "HVBUS_L04_P019" (solid, remove dead copper, pour order 19): 350,542.44 367.56,560 845,560 860,545 860,291.61 724.62,156.23 724.62,13.62 717,6 447.5,6 435,18.5 435,260.56 350,360
PGND on MidLayer3 "PGND_L04_P018" (solid, remove dead copper, pour order 18): -405,1205 -382.97,1227.03 48.59,1227.03 55.14,1220.48 55.14,1039.86 195.49,899.51 820.49,899.51 855,865 855,660.44 844.56,650 -36.37,650 -207.39,478.98 -207.39,10.89 -212.29,5.99 -487.49,5.99 -505,23.5 -505,142.11 -405,242.11

## Other copper
Top Layer:
  region net VSSA: -714.85,1743.71 -709.35,1749.21 -639.21,1749.21 -635,1745 -635,1665 -640,1660 -708.03,1660 -715.09,1667.06 -715.09,1730
Bottom Layer:
  region net INGND: -925.43,765.43 -914,754 -914,726.06 -930.13,709.92 -971.2,709.92
  region net PGND: 367.56,712.56 385,730 831.22,730 852.5,708.73 852.5,662.5 840,650 385,650 367.56,667.44