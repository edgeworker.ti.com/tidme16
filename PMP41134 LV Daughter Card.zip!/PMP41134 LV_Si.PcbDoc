# Altium PCB PMP41134 LV_Si.PcbDoc (part 3 of 3)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 67.42 x 50.27 mm, 6 copper layers (Top Layer, MidLayer1, MidLayer2, MidLayer3, MidLayer4, Bottom Layer), stack 1.844 mm thick; 51 components, 27 nets, 140 pads, 574 vias.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=0.025 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=0.025 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p1: expansion=0.05 istentingtop=FALSE
Width [All] p1: maxlimit=2.54 minlimit=0.152 preferedwidth=0.254 substack1={A02F224D-4808-492E-A71F-5F5656FBF0D4} substack2={B838D286-A00B-4EE2-88E1-F79279CC64B4} substack3={0D253197-D122-4D2B-9584-B8C12AA3806F} substack4={88BCB183-C685-456E-B90A-365A53404C2C} substack5={4C8C2325-90D5-40B8-8B6B-4F66D44EFE25} substack6={553D66F5-99EF-40B1-BA7C-73E3B04B176F} substack7={FF0C9878-5A48-402E-B013-8E2EEFCEDCCB} substack8={5BB5B65B-6C7F-4868-A6AE-66DD57ADDCBD} substack9={65866CD6-1929-42AF-BAA8-019D5E6BA212} substack10={590F0BEA-1E04-4904-B9C9-D9D160075BC2} substack11={B2AC4F48-1A5F-44D7-A91B-3BAADFDAAED0} substack12={DD3D4156-A54D-4E1F-B7FF-E5EF72C45496} substack13={7CC4AE65-1EB7-43C1-8FCA-3677EE54F737} substack14={E8C37195-128A-4AA0-B681-9B6788FCEC2F} substack15={92E0C252-34CC-4501-B85F-B111C59C3287} substack16={732F7058-E977-446F-8A06-ECA871B5D75E} substack17={990DA1BC-A1DE-47D8-A675-B5A4E74B5332} checkconnectedcopper=TRUE
14 further rules are at their usual default settings.

## Classes and differential pairs
net class LVSW2: LV_SW2 NetC11_2 NetD3_2 NetQ7_4 Sec_HB
net class LVSW1: LV_SW1 NetC5_2 NetD1_2 NetQ1_4 Sec_HA
net class 48V+: 48Vo+
net class SGND: 12Vs LV_PWM1H LV_PWM1L LV_PWM2H LV_PWM2L LV_SW1 LV_SW2 NetC1_1 NetC4_1 NetC5_2 NetC7_1 NetC10_1 NetC11_2 Sec_HA Sec_HB Sec_LA Sec_LB SGND
component class Header: J1

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C1 "CC0402JRNPO9BN101" 0402 5.537,40.391 r270 top value=100pF
C2 "GRM188Z71C475KE21D" 0603 12.022,46.571 r0 bottom value=4.7uF
C3 "CGA2B3X7R1E104K050BB" 0402 12.141,47.955 r0 bottom value=0.1uF
C4 "CC0402JRNPO9BN101" 0402 5.537,43.032 r90 top value=100pF
C5 "GRM31CC72A475KE11L" FP-GRM31CC72A475KE11L_1206-MFG 14.986,42.277 r90 bottom value=4.7µF
C6 "GRM155R62A104KE14D" 0402 14.707,41.727 r270 top value=0.1uF
C7 "CC0402JRNPO9BN101" 0402 44.348,40.319 r270 top value=100pF
C8 "GRM188Z71C475KE21D" 0603 37.439,46.531 r180 top value=4.7uF
C9 "CGA2B3X7R1E104K050BB" 0402 37.16,47.928 r180 top value=0.1uF
C10 "CC0402JRNPO9BN101" 0402 44.348,42.94 r90 top value=100pF
C11 "GRM31CC72A475KE11L" FP-GRM31CC72A475KE11L_1206-MFG 34.341,41.935 r90 bottom value=4.7µF
C12 "GRM155R62A104KE14D" 0402 34.62,42.24 r270 top value=0.1uF
D1 "B130AF-13" SMAF 22.315,43.943 r0 bottom value=30V
D2 "B130AF-13" SMAF -0.305,44.501 r180 bottom value=30V
D3 "B130AF-13" SMAF 29.89,45.618 r180 bottom value=30V
D4 "B130AF-13" SMAF 49.403,44.171 r0 bottom value=30V
J1 "850-40-006-20-001000" Mill-Max_850-40-006-20-001000 -6.35,15 r0 top
Q1 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 20.241,17.659 r90 bottom
Q2 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 9.822,17.659 r90 bottom
Q3 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 20.241,23.753 r90 bottom
Q4 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 9.822,23.753 r90 bottom
Q5 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 20.241,29.846 r90 bottom
Q6 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 9.822,29.846 r90 bottom
Q7 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 31.713,35.913 r270 bottom
Q8 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 42.209,35.913 r270 bottom
Q9 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 31.713,29.82 r270 bottom
Q10 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 42.209,29.82 r270 bottom
Q11 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 31.713,23.726 r270 bottom
Q12 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 42.209,23.726 r270 bottom
Q13 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 20.241,35.94 r90 bottom
Q14 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 9.822,35.94 r90 bottom
Q15 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 31.713,17.632 r270 bottom
Q16 "BSC023N08NS5SCATMA1" FP-BSC023N08NS5SCATMA1_WSON8-MFG 42.209,17.632 r270 bottom
R1 "RC0603FR-07100RL" 0603 3.277,40.876 r0 top value=100
R2 "RC0603FR-07100RL" 0603 3.277,42.52 r0 top value=100
R3 "ERJ-2RKF1002X" 0402 16.154,37.27 r90 bottom value=10.0k
R4 "RC0603FR-07100RL" 0603 46.704,40.919 r180 top value=100
R5 "ERJ-2RKF1002X" 0402 5.662,37.118 r90 bottom value=10.0k
R6 "RC0603FR-07100RL" 0603 46.672,42.492 r180 top value=100
R7 "CRCW12062R00JNEA" 1206 17.504,42.37 r270 bottom value=2.0
R8 "CRCW12062R00JNEA" 1206 4.47,43.17 r270 bottom value=2.0
R9 "CRCW12061R10JNEA" 1206 21.475,41.276 r180 bottom value=1.1
R10 "CRCW12061R10JNEA" 1206 0.508,40.894 r0 bottom value=1.1
R15 "CRCW12061R10JNEA" 1206 29.213,41.811 r90 bottom value=1.1
R16 "CRCW12061R10JNEA" 1206 48.793,41.469 r0 bottom value=1.1
R17 "CRCW12062R00JNEA" 1206 31.928,41.811 r90 bottom value=2.0
R18 "CRCW12062R00JNEA" 1206 44.581,43.49 r90 bottom value=2.0
R35 "ERJ-2RKF1002X" 0402 35.857,34.725 r270 bottom value=10.0k
R44 "ERJ-2RKF1002X" 0402 46.424,34.715 r270 bottom value=10.0k
U1 "UCC27301A-Q1" DDA0008A-MFG 10.031,42.977 r180 bottom
U2 "UCC27301A-Q1" DDA0008A-MFG 39.446,42.824 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52, body extent -0.55,-0.3 0.55,0.3, height 0.6
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69, body extent -0.87,-0.47 0.87,0.47, height 1
1206 [mm] "1206 from SM-752 data"
  rect 1.3x1.85 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.4,-1.21 2.4,1.21, body extent -1.7,-0.9 1.7,0.9, height 1.35
DDA0008A-MFG [mm]
  rrect17% 1.55x0.6 smd paste+0 mask+0: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
  rrect3% 2.95x4.9 smd paste-1000 mask-1000: 9(0,0)
  silkscreen extent -4.15,-2.83 2,2.83, body extent -3.01,-2.45 3.01,2.45, height 1.7
FP-BSC023N08NS5SCATMA1_WSON8-MFG [mm]
  rrect10% 3.04x1.025 smd paste-1000 mask-1000: 1-2-3(-0.635,-2.738)
  rrect20% 0.5x1.025 smd paste-1000 mask+0: 4(1.905,-2.738)
  rrect2% 4.31x4.48 smd paste-1000 mask-1000: 5-6-7-8(0,1.01)
  silkscreen extent -2.78,-3.92 2.78,3.03, body extent -2.5,-3 2.5,3, height 0.75
FP-GRM31CC72A475KE11L_1206-MFG [mm]
  rrect9% 1.15x1.8 smd paste+0 mask+0: 1(-1.575,0) 2(1.575,0)
  silkscreen extent -0.63,-0.95 0.63,0.95, body extent -1.6,-0.8 1.6,0.8, height 1.9
Mill-Max_850-40-006-20-001000 [mm] "Header, 50mil, 6x1, R/A, TH"
  rect 1x1 hole 0.65: 1(-3.175,2.299)
  round 1 hole 0.65: 2(-1.905,2.299) 3(-0.635,2.299) 4(0.635,2.299) 5(1.905,2.299) 6(3.175,2.299)
  silkscreen extent -4.37,-1.1 4,1.1, body extent -4,-4.1 4,2.5, height 2.21
SMAF [mm] "SMD, 2-Leads, Body 3.8x2.5mm"
  rect 1.24x1.89 smd: 1(-2.04,0) 2(2.04,0)
  silkscreen extent -3.4,-1.3 2.8,1.3, body extent -2.35,-1.25 2.35,1.25, height 1

## Part data
C1 C4 C7 C10: library part CMP-0006303-2, "CAP, CERM, 100 pF, 50 V, +/- 5%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer="Yageo America", Supplier Part Number 1=311-1024-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=100pF
C2 C8: library part CMP-0064936-4, "CAP, CERM, 4.7 uF, 16 V,+/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer=MuRata, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=4.7uF
C3 C9: library part CMP-0080610-1, "CAP, CERM, 0.1 µF, 25 V,+/- 10%, X7R, AEC-Q200 Grade 1, 0402", Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-6902-1-ND, TempCo=X7R, Tolerance_%=10%, Value2=25V, ValueDisplayed=0.1µF
C5 C11: library part CMP-0089881-1, "4.7µF ±10% 100V Ceramic Capacitor X7S 1206 (3216 Metric)", Digikey Part Number=490-18620-1-ND, Manufacturer=Murata, Mouser Part Number=81-GRM31CC72A475KE1L, Operating Temperature Range="-55°C to +125°C", TempCo=22%, Temperature Characteristic=X7S, Tolerance_%=10%, ValueDisplayed=4.7uF
C6 C12: library part CMP-0006618-1, "CAP, CERM, 0.1 uF, 100 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-10458-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=100V, ValueDisplayed=0.1uF
D1 D2 D3 D4: library part CMP-0085599-1, "Diode, Schottky, 30 V, 1 A, SMAF", Manufacturer="Diodes Inc.", Value1=1A, Value2=0.5V
J1: library part CMP-0055095-1, "Header, 1.27 mm, 6x1, Tin, R/A, TH", Manufacturer=Mill-Max
Q1 Q2 Q3 Q4 Q5 Q6 Q7 Q8 Q9 Q10 Q11 Q12 Q13 Q14 Q15 Q16: library part CMP-0123078-1, "N-Channel 80 V 202A (Tc) 188W (Tc) Surface Mount PG-WSON-8-2", Digikey Part Number=448-BSC023N08NS5SCATMA1CT-ND, Drain To Source Breakdown Voltage=80V, Input Capacitance At Vds="5200pF @ 40V", Manufacturer=Infineon, Mouser Part Number=726-S23N08NS5SCATMA1, Operating Temperature Range="-55°C to 175°C", Power_W=3W, Pulse Drain Current=808A, Typ Forward Diode Voltage=0.84V
R1 R2 R4 R6: library part CMP-0022736-4, "RES, 100, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-100HRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=100R, ValueDisplayed=100
R3 R5 R35 R44: library part CMP-0026658-1, "RES, 10.0 k, 1%, 0.1 W, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P10.0KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10.0k
R7 R8 R17 R18: library part CMP-0018648-3, "RES, 2.0, 5%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-2.0ECT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.25W, Value_Code=2R00, ValueDisplayed=2.0
R9 R10 R15 R16: library part CMP-0018618-3, "RES, 1.1, 5%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-1.1ECT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.25W, Value_Code=1R10, ValueDisplayed=1.1
U1 U2: library part CMP-0123128-1, "Automotive 120V, 3.7A/4.5A Half-Bridge Driver with 8V UVLO, Interlock and Enable", Manufacturer="Texas Instruments", Max Supply Voltage=17V, Min Supply Voltage=8V, Nominal Supply Current=0.11-1.4mA, Operating Temperature Range="-40°C to +150°C"

## Free pads (board coordinates)
  round 5.6 hole 4.5: 1(5,3.3) 1(20.011,3.3) 1(35.048,3.3) 1(50.034,3.3)

## Via types
v1: diameter 0.5, hole 0.254, Top Layer to Bottom Layer, tented both sides, 429 vias
v2: diameter 0.5, hole 0.254, Top Layer to Bottom Layer, 110 vias
v3: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, tented both sides, 33 vias
v4: diameter 0.61, hole 0.203, Top Layer to Bottom Layer, tented both sides, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
12Vs: C2.2 C3.2 C8.2 C9.2 J1.1 U1.1 U2.1 | length 79.2
  Top Layer w0.508: 35.459,48.004 35.484,47.928 C9.2@36.56,47.928 36.56,44.775 36.606,44.729 U2.1@36.746,44.729
  Top Layer w0.762: J1.1@-9.579,17.299 -9.579,40.053 -2.87,46.761 v3@13.572,46.761 ; 13.773,46.761 14.929,47.928 35.382,47.928
  Bottom Layer w0.508: U1.1@12.731,44.882 12.736,44.887 12.736,47.95 C3.2@12.741,47.955 C3.2@12.787,47.909 ; C2.2@12.822,46.571 v3(13.572,46.571)
48Vo+: pad.1@50.034,3.3 Q1.5-6-7-8 Q3.5-6-7-8 Q5.5-6-7-8 Q7.5-6-7-8 Q9.5-6-7-8 Q11.5-6-7-8 Q13.5-6-7-8 Q15.5-6-7-8
  other v1: 29.469,17.594 30.104,17.594 30.739,17.594 31.374,17.594 21.082,17.746 21.717,17.746 22.352,17.746 22.987,17.746 29.292,18.271 29.927,18.271 30.562,18.271 31.197,18.271 20.904,18.423 21.539,18.423 22.174,18.423 22.809,18.423 29.469,18.917 30.104,18.917 30.739,18.917 31.374,18.917 21.082,19.07 21.717,19.07 22.352,19.07 22.987,19.07 29.128,23.055 29.763,23.055 30.398,23.055 31.033,23.055 20.74,23.207 21.375,23.207 22.01,23.207 22.645,23.207 29.306,23.701 29.941,23.701 30.576,23.701 31.211,23.701 20.918,23.853 21.553,23.853 22.188,23.853 22.823,23.853 29.128,24.378 29.763,24.378 30.398,24.378 31.033,24.378 20.74,24.531 21.375,24.531 22.01,24.531 22.645,24.531 29.306,25.025 29.941,25.025 30.576,25.025 31.211,25.025 20.918,25.177 21.553,25.177 22.188,25.177 22.823,25.177 29.357,28.681 29.992,28.681 30.627,28.681 31.262,28.681 20.969,28.833 21.604,28.833 22.239,28.833 22.874,28.833 29.535,29.327 30.17,29.327 30.805,29.327 31.44,29.327 21.147,29.479 21.782,29.479 22.417,29.479 23.052,29.479 29.241,29.956 29.876,29.956 30.511,29.956 31.146,29.956 20.853,30.109 21.488,30.109 22.123,30.109 22.758,30.109 29.419,30.602 30.054,30.602 30.689,30.602 31.324,30.602 21.031,30.755 21.666,30.755 22.301,30.755 22.936,30.755 29.077,34.965 29.712,34.965 30.347,34.965 30.982,34.965 20.69,35.117 21.325,35.117 21.96,35.117 22.595,35.117 29.255,35.611 29.89,35.611 30.525,35.611 31.16,35.611 20.867,35.763 21.502,35.763 22.137,35.763 22.772,35.763 28.962,36.24 29.597,36.24 30.232,36.24 30.867,36.24 20.574,36.392 21.209,36.392 21.844,36.392 22.479,36.392 29.14,36.886 29.775,36.886 30.41,36.886 31.045,36.886 20.752,37.039 21.387,37.039 22.022,37.039 22.657,37.039
  other v2: 45.85,8.127 46.485,8.127 47.12,8.127 47.755,8.127 48.39,8.127 49.025,8.127 49.66,8.127 50.295,8.127 50.93,8.127 51.565,8.127 52.2,8.127 52.835,8.127 53.47,8.127 54.105,8.127 46.167,8.762 46.802,8.762 47.437,8.762 48.072,8.762 48.707,8.762 49.342,8.762 49.977,8.762 50.612,8.762 51.247,8.762 51.882,8.762 52.517,8.762 53.152,8.762 53.787,8.762 54.422,8.762
LV_PWM1H: J1.2 R1.1 | length 28
  Top Layer w0.508: J1.2@-8.255,17.299 -8.255,30.145 2.231,40.63 2.231,40.655 2.452,40.876 R1.1@2.477,40.876
LV_PWM1L: J1.3 R2.1 | length 35.5
  Top Layer w0.508: v4(1.556,42.52) R2.1@2.477,42.52
  MidLayer3 w0.508: J1.3@-6.985,17.299 -6.985,16.18 -6.223,15.418 -2.794,15.418 -1.727,16.485 -1.727,39.237 v4(1.556,42.52)
LV_PWM2H: J1.4 R4.1 | length 89.7
  Top Layer w0.508: R4.1@47.549,40.874 R4.1@47.504,40.919 47.725,41.14 v3(48.739,41.14)
  MidLayer3 w0.508: J1.4@-5.715,17.299 -5.715,42.596 0.432,48.743 44.069,48.743 49.835,42.977 49.835,41.91 49.065,41.14 v3(48.739,41.14)
LV_PWM2L: J1.5 R6.1 | length 83.7
  Top Layer w0.508: R6.1@47.472,42.492 47.608,42.628 v4@48.614,42.628
  MidLayer3 w0.508: J1.5@-4.445,17.299 -4.445,42.266 1.092,47.803 42.037,47.803 47.212,42.628 v4(48.641,42.628)
LV_SW1: C5.1 C6.2 pad.1@20.011,3.3 Q1.1-2-3 Q2.5-6-7-8 Q3.1-2-3 Q4.5-6-7-8 Q5.1-2-3 Q6.5-6-7-8 Q13.1-2-3 Q14.5-6-7-8 R3.1 U1.4 | length 6.3
  Top Layer w0.508: v3(13.822,41.026) 14.661,41.026 14.707,41.072 C6.2@14.707,41.127
  Bottom Layer w0.508: U1.4@12.731,41.072 12.777,41.026 v3(13.822,41.026) 14.88,41.026 C5.1@14.986,40.92
  Bottom Layer w0.762: 14.88,37.904 14.88,40.815 C5.1@14.986,40.92
  other v1: 9.944,16.747 10.503,16.747 11.062,16.747 11.621,16.747 12.198,16.751 9.95,17.299 10.514,17.299 11.078,17.299 11.642,17.299 12.206,17.299 9.809,17.838 10.373,17.838 10.937,17.838 11.501,17.838 12.065,17.838 10.043,18.392 10.607,18.392 11.171,18.392 11.735,18.392 12.299,18.392 9.902,18.931 10.466,18.931 11.03,18.931 11.594,18.931 12.158,18.931 9.571,22.881 10.091,22.881 10.65,22.881 11.209,22.881 11.768,22.881 12.344,22.885 9.687,23.429 10.207,23.429 10.751,23.429 11.295,23.429 11.84,23.429 12.384,23.429 9.551,23.967 10.071,23.967 10.615,23.967 11.159,23.967 11.704,23.967 12.248,23.967 9.687,24.489 10.207,24.489 10.751,24.489 11.295,24.489 11.84,24.489 12.384,24.489 9.551,25.027 10.071,25.027 10.615,25.027 11.159,25.027 11.704,25.027 12.248,25.027 9.537,28.863 10.075,28.863 10.634,28.863 11.193,28.863 11.752,28.863 12.329,28.863 9.798,29.403 10.335,29.403 10.84,29.403 11.345,29.403 11.85,29.403 12.355,29.403 9.537,29.975 10.083,29.975 10.588,29.975 11.093,29.975 11.598,29.975 12.103,29.975 9.919,30.548 10.461,30.548 10.967,30.548 11.472,30.548 11.977,30.548 12.482,30.548 9.691,31.12 10.209,31.12 10.714,31.12 11.219,31.12 11.724,31.12 12.229,31.12 9.423,34.722 9.973,34.71 10.532,34.71 11.091,34.71 11.65,34.71 12.227,34.71 9.728,35.306 10.269,35.295 10.794,35.295 11.32,35.295 11.846,35.295 12.372,35.295 9.467,35.834 10.006,35.834 10.532,35.834 11.057,35.834 11.583,35.834 12.109,35.834 9.849,36.374 10.4,36.373 10.926,36.373 11.452,36.373 11.978,36.373 12.372,36.373 9.621,36.907 10.137,36.912 10.663,36.912 11.189,36.912 11.715,36.912 12.241,36.912
  other v2: 16.056,8.28 16.691,8.28 17.326,8.28 17.961,8.28 18.596,8.28 19.231,8.28 19.866,8.28 20.501,8.28 21.136,8.28 21.771,8.28 22.406,8.28 23.041,8.28 23.676,8.28 24.311,8.28 16.373,8.915 17.008,8.915 17.643,8.915 18.278,8.915 18.913,8.915 19.548,8.915 20.183,8.915 20.818,8.915 21.453,8.915 22.088,8.915 22.723,8.915 23.358,8.915 23.993,8.915
LV_SW2: C11.1 C12.2 pad.1@35.048,3.3 Q7.1-2-3 Q8.5-6-7-8 Q9.1-2-3 Q10.5-6-7-8 Q11.1-2-3 Q12.5-6-7-8 Q15.1-2-3 Q16.5-6-7-8 R35.1 U2.4 | length 6.5
  Top Layer w0.508: C12.2@34.62,41.64 34.62,41.54 35.24,40.92 v3(35.704,40.92) U2.4@36.745,40.92
  Bottom Layer w0.508: C11.1@34.738,40.039 34.417,40.36 C11.1@34.341,40.36 34.662,40.681 35.465,40.681 v3(35.704,40.92)
  Bottom Layer w0.762: 34.738,38.136 C11.1@34.738,40.039
  other v1: 39.62,16.778 40.179,16.778 40.738,16.778 41.297,16.778 41.885,16.781 42.461,16.798 39.528,17.352 40.087,17.352 40.646,17.352 41.205,17.352 41.785,17.352 42.361,17.369 39.612,17.922 40.171,17.922 40.73,17.922 41.289,17.922 41.862,17.926 42.438,17.943 39.522,18.471 40.081,18.471 40.64,18.471 41.199,18.471 41.775,18.475 42.351,18.492 39.625,18.979 40.184,18.979 40.743,18.979 41.302,18.979 41.879,18.983 42.455,19 39.645,22.663 40.204,22.663 40.763,22.663 41.322,22.663 41.911,22.666 42.5,22.677 39.553,23.237 40.112,23.237 40.671,23.237 41.23,23.237 41.811,23.237 42.4,23.247 39.608,23.839 40.167,23.839 40.726,23.839 41.285,23.839 41.873,23.842 42.462,23.853 39.515,24.413 40.074,24.413 40.633,24.413 41.192,24.413 41.773,24.413 42.362,24.424 39.571,24.973 40.13,24.973 40.689,24.973 41.248,24.973 41.825,24.977 42.414,24.988 39.654,28.994 40.213,28.994 40.772,28.994 41.331,28.994 41.893,28.997 42.484,28.997 39.561,29.568 40.12,29.568 40.679,29.568 41.238,29.568 41.83,29.571 42.422,29.571 39.537,30.083 40.096,30.083 40.655,30.083 41.214,30.083 41.801,30.083 42.393,30.083 39.446,30.616 40.005,30.616 40.564,30.616 41.123,30.616 41.699,30.616 42.291,30.616 39.573,31.123 40.132,31.123 40.691,31.123 41.25,31.123 41.827,31.127 42.419,31.127 39.549,34.546 40.108,34.546 40.667,34.546 41.226,34.546 41.803,34.55 42.371,34.55 39.729,35.104 40.253,35.104 40.777,35.104 41.301,35.104 41.824,35.104 42.393,35.104 39.468,35.671 39.991,35.671 40.515,35.671 41.039,35.671 41.563,35.671 42.131,35.671 39.729,36.237 40.253,36.237 40.777,36.237 41.301,36.237 41.824,36.237 42.393,36.237 39.468,36.804 39.991,36.804 40.515,36.804 41.039,36.804 41.563,36.804 42.131,36.804
  other v2: 30.753,8.178 31.388,8.178 32.023,8.178 32.658,8.178 33.293,8.178 33.928,8.178 34.563,8.178 35.198,8.178 35.833,8.178 36.468,8.178 37.103,8.178 37.738,8.178 38.373,8.178 39.008,8.178 31.07,8.813 31.705,8.813 32.34,8.813 32.975,8.813 33.61,8.813 34.245,8.813 34.88,8.813 35.515,8.813 36.15,8.813 36.785,8.813 37.42,8.813 38.055,8.813 38.69,8.813 39.325,8.813
NetC1_1: C1.1 R1.2 U1.5 | length 3.4
  Top Layer w0.508: R1.2@4.077,40.876 5.491,40.876 5.537,40.922 C1.1@5.537,40.991 5.537,41.026 5.583,41.072 v3(6.267,41.072)
  Bottom Layer w0.508: v3(6.267,41.072) U1.5@7.331,41.072
NetC4_1: C4.1 R2.2 U1.6 | length 3.3
  Top Layer w0.508: R2.2@4.077,42.52 4.121,42.476 5.493,42.476 C4.1@5.537,42.432 5.537,42.408 5.583,42.362 v3(6.288,42.362)
  Bottom Layer w0.508: v3(6.288,42.362) 7.311,42.362 U1.6@7.331,42.342
NetC5_2: C5.2 C6.1 U1.2 | length 3.5
  Top Layer w0.508: C6.1@14.707,42.327 v3(14.707,43.527)
  Bottom Layer w0.381: U1.2@12.731,43.612 12.841,43.721 C5.2@14.683,43.721 ; C5.2@14.761,43.627 C5.2@14.986,43.852
NetC7_1: C7.1 R4.2 U2.5 | length 3.8
  Top Layer w0.508: U2.5@42.146,40.919 C7.1@44.348,40.919 R4.2@45.904,40.919
NetC10_1: C10.1 R6.2 U2.6 | length 3.9
  Top Layer w0.508: U2.6@42.146,42.189 44.298,42.189 44.348,42.24 C10.1@44.348,42.34 44.348,42.37 44.394,42.416 45.796,42.416 R6.2@45.872,42.492
NetC11_2: C11.2 C12.1 U2.2 | length 3.8
  Top Layer w0.508: C12.1@34.62,42.84 34.62,42.94 34.666,42.986 34.766,42.986 35.255,43.474 v3(35.704,43.474) 36.731,43.474 U2.2@36.746,43.459
  Bottom Layer w0.508: C11.2@34.341,43.51 34.377,43.474 v3(35.704,43.474)
NetD1_2: D1.2 R9.1 | length 3.3
  Bottom Layer w0.381: R9.1@22.925,41.276 R9.1@23.155,41.506
  Bottom Layer w0.508: R9.1@23.155,41.506 23.242,41.593 23.242,42.596 23.897,43.252 23.989,43.252 24.355,43.618 D1.2@24.355,43.943
NetD2_2: D2.2 R10.1 | length 3.3
  Bottom Layer w0.508: D2.2@-2.327,44.116 -2.327,43.791 -1.238,42.701 -1.238,41.626 R10.1@-0.957,41.345
NetD3_2: D3.2 R15.2 | length 3.1
  Bottom Layer w0.508: D3.2@27.85,45.618 28.216,45.252 28.216,43.954 28.513,43.657 28.817,43.657 R15.2@29.213,43.261
NetD4_2: D4.2 R16.2 | length 3.2
  Bottom Layer w0.508: R16.2@50.199,41.39 50.199,41.7 50.639,42.14 50.7,42.14 51.321,42.761 51.321,43.902 D4.2@51.475,44.057
NetQ1_4: Q1.4 Q3.4 Q5.4 Q13.4 R3.2 R7.2 R9.2 | length 29.2
  Bottom Layer w0.381: R3.2@16.154,37.718 16.154,37.795 R3.2@16.264,37.904 ; R3.2@16.264,37.845 Q13.4@17.504,37.845 ; Q1.4@17.504,19.564 17.563,19.624 18.173,19.624 18.495,19.946 18.495,25.658 ; Q3.4@17.504,25.658 18.495,25.658 ; Q5.4@17.504,31.751 18.495,31.751 ; Q13.4@17.508,37.841 18.19,37.841 18.495,37.536 18.495,31.751 ; R9.2@19.844,41.095 R9.2@20.025,41.276 ; 18.495,25.658 18.495,31.751
  Bottom Layer w0.508: Q13.4@17.508,37.841 Q13.4@17.504,37.845 17.504,41.095 R9.2@19.844,41.095
NetQ2_4: Q2.4 Q4.4 Q6.4 Q14.4 R5.2 R8.2 R10.2 | length 30.5
  Bottom Layer w0.381: R5.2@5.662,37.736 5.771,37.845 Q14.4@7.084,37.845 7.144,37.786 7.854,37.786 8.077,37.562 8.077,31.751 ; Q2.4@7.084,19.564 7.144,19.624 7.886,19.624 8.077,19.815 8.077,25.658 ; Q4.4@7.084,25.658 8.077,25.658 ; Q6.4@7.084,31.751 8.077,31.751 ; 8.077,25.658 8.077,31.751
  Bottom Layer w0.508: R10.2@1.943,41.345 2.076,41.478 R8.2@4.47,41.478 ; R8.2@4.47,41.72 4.8,41.39 4.8,39.677 5.662,38.816 R5.2@5.662,37.659
NetQ7_4: Q7.4 Q9.4 Q11.4 Q15.4 R15.1 R17.1 R35.2 | length 33.6
  Bottom Layer w0.381: R17.1@31.928,40.361 32.114,40.361 32.573,39.901 32.573,39.385 33.452,38.506 33.452,34.008 ; Q15.4@34.45,15.727 34.427,15.751 33.709,15.751 33.452,16.008 33.452,21.923 ; Q11.4@34.45,21.821 33.554,21.821 33.452,21.923 ; Q9.4@34.45,27.915 33.528,27.915 33.452,27.838 ; R35.2@35.811,34.008 Q7.4@34.45,34.008 33.452,34.008 ; 33.452,21.923 33.452,27.838 ; 33.452,27.838 33.452,34.008
  Bottom Layer w0.508: R15.1@29.213,40.361 29.391,40.538 31.75,40.538 R17.1@31.928,40.361 ; R35.2@35.811,34.008 35.857,34.054 R35.2@35.857,34.125
NetQ8_4: Q8.4 Q10.4 Q12.4 Q16.4 R16.1 R18.1 R44.2 | length 34.9
  Bottom Layer w0.381: R18.1@43.967,41.398 43.967,34.008 ; Q16.4@44.946,15.727 44.923,15.751 44.191,15.751 43.967,15.974 43.967,21.821 ; Q12.4@44.946,21.821 43.967,21.821 ; Q10.4@44.946,27.915 44.044,27.915 43.967,27.838 ; R44.2@46.424,34.008 Q8.4@44.946,34.008 43.967,34.008 ; R16.1@46.884,40.735 47.343,41.194 R16.1@47.343,41.469 ; 43.967,21.821 43.967,27.838 ; 43.967,27.838 43.967,34.008
  Bottom Layer w0.508: R18.1@44.581,42.04 44.854,41.767 47.046,41.767 R16.1@47.343,41.469
Sec_HA: D1.1 R7.1 U1.3 | length 9.3
  Bottom Layer w0.381: R7.1@16.769,43.431 16.769,43.536 17.229,43.995 R7.1@17.504,43.995
  Bottom Layer w0.508: U1.3@12.731,42.342 16.025,42.342 16.833,43.149 16.833,43.424 17.229,43.82 R7.1@17.504,43.82 ; R7.1@17.556,43.943 D1.1@20.275,43.943
Sec_HB: D3.1 R17.2 U2.3 | length 8.3
  Top Layer w0.508: v3(35.704,42.14) 35.707,42.143 36.7,42.143 U2.3@36.746,42.189
  Bottom Layer w0.381: R17.2@31.928,43.261 R17.2@32.036,43.368
  Bottom Layer w0.508: R17.2@31.621,42.954 R17.2@31.928,43.261 ; R17.2@31.955,43.371 D3.1@31.955,45.745 ; R17.2@32.18,42.954 v3(32.18,42.277) 32.316,42.14 v3(35.704,42.14)
Sec_LA: D2.1 R8.1 U1.8 | length 5.8
  Bottom Layer w0.508: D2.1@1.753,44.116 1.753,44.254 2.119,44.62 R8.1@4.47,44.62 ; R8.1@4.745,44.378 5.249,44.882 U1.8@7.331,44.882
Sec_LB: D4.1 R18.2 U2.8 | length 5.6
  Top Layer w0.381: U2.8@42.146,44.729 U2.8@42.146,44.729 ; v3@43.28,44.728 v3(43.281,44.728)
  Top Layer w0.508: U2.8@42.146,44.729 43.101,44.728 v3@43.28,44.728
  Bottom Layer w0.508: v3(43.281,44.728) 44.369,44.728 R18.2@44.581,44.94 ; R18.2@44.736,44.728 47.029,44.728 47.395,44.362 D4.1@47.395,44.057
SGND: C1.2 C2.1 C3.1 C4.2 C7.2 C8.1 C9.1 C10.2 J1.6 pad.1@5,3.3 Q2.1-2-3 Q4.1-2-3 Q6.1-2-3 Q8.1-2-3 Q10.1-2-3 Q12.1-2-3 Q14.1-2-3 Q16.1-2-3 R5.1 R44.1 U1.7 U1.9 U2.7 U2.9 | length 36.6
  Top Layer w0.508: C1.2@5.537,39.791 5.537,39.795 5.583,39.841 v3(6.212,39.841) ; C4.2@5.537,43.632 v3(6.288,43.632) ; C9.1@37.76,47.928 37.86,47.928 37.906,47.882 37.906,47.782 38.218,47.47 38.218,46.553 38.254,46.516 38.254,44.016 v3(38.796,43.474) U2.9@39.446,42.824 40.081,43.459 U2.7@42.146,43.459 42.161,43.474 44.302,43.474 44.348,43.52 C10.2@44.348,43.54 ; C7.2@44.302,39.865 44.348,39.819 C7.2@44.348,39.719 44.38,39.751 v3(44.882,39.751)
  MidLayer3 w1.016: v3(4.394,37.897) 4.648,38.151 4.648,42.443 5.837,43.632 v3(6.288,43.632) ; v3(43.29,43.474) 43.798,42.966 43.798,39.243 44.946,38.095 v3(45.819,38.095)
  Bottom Layer w0.508: v3(6.288,43.632) 7.311,43.632 U1.7@7.331,43.612 9.396,43.612 U1.9@10.031,42.977 v3(10.681,43.627) 11.215,44.16 11.215,46.564 C2.1@11.222,46.571 11.222,47.736 11.441,47.955 C3.1@11.541,47.955
  other v1: 1.144,14.647 1.144,15.207 1.144,15.766 1.144,16.325 1.144,16.885 1.144,17.444 48.26,19.533 48.26,20.147 47.422,20.217 1.222,20.471 48.26,20.761 47.422,20.817 1.222,21.031 48.26,21.376 47.422,21.416 1.222,21.59 48.26,21.99 47.422,22.015 1.222,22.15 47.422,22.614 1.222,22.709 48.26,23.219 1.222,23.268 47.422,23.812 48.26,23.833 47.422,24.411 48.26,24.448 47.422,25.01 48.26,25.062 47.422,25.61 48.26,25.677 1.157,25.712 47.422,26.209 1.157,26.271 1.157,26.83 48.26,26.906 1.157,27.39 47.422,27.407 48.26,27.52 1.157,27.949 47.422,28.006 48.26,28.134 1.157,28.509 47.422,28.605 48.26,28.749 47.422,29.204 48.26,29.363 47.422,29.803 48.26,30.592 47.422,31.002 1.168,31.063 48.26,31.207 47.422,31.601 1.168,31.622 48.26,31.821 1.168,32.182 47.422,32.2 48.26,32.435 1.168,32.741 47.422,32.799 48.26,33.05 1.168,33.3 47.422,33.398 1.168,33.86 48.26,34.279 47.422,34.596 48.26,34.893 47.422,35.195 48.26,35.507 47.422,35.795 48.26,36.122 47.422,36.394 48.26,36.736 47.422,36.993
  other v2: 0.816,8.356 1.451,8.356 2.086,8.356 2.721,8.356 3.356,8.356 3.991,8.356 4.626,8.356 5.261,8.356 5.896,8.356 6.531,8.356 7.166,8.356 7.801,8.356 8.436,8.356 9.071,8.356 1.133,8.991 1.768,8.991 2.403,8.991 3.038,8.991 3.673,8.991 4.308,8.991 4.943,8.991 5.578,8.991 6.213,8.991 6.848,8.991 7.483,8.991 8.118,8.991 8.753,8.991
  other v3: 38.796,40.874 40.096,40.874 9.381,41.027 10.681,41.027 38.796,42.174 40.096,42.174 9.381,42.327 10.681,42.327 40.096,43.474 9.381,43.627 38.796,44.774 40.096,44.774 9.381,44.927 10.681,44.927

## Polygon pours and split planes (outlines as drawn)
LV_SW1 on Top Layer "LV_SW1_L01_P042" (solid, remove dead copper, pour order 42): 15.088,-0.838 15.088,10.084 8.592,15.188 8.592,37.305 8.917,37.63 16.599,37.63 17.043,37.186 17.043,18.143 25.011,11.023 25.011,-0.838
LV_SW2 on Top Layer "LV_SW2_L01_P043" (solid, remove dead copper, pour order 43): 34.696,-0.831 39.993,-0.838 39.993,9.945 43.28,13.232 43.28,36.882 42.532,37.63 35.456,37.63 34.696,36.87
SGND on Top Layer "SGND_L01_P044" (solid, remove dead copper, pour order 44): -10.897,10.338 -1.273,10.338 -0.762,10.816 -0.762,36.043 2.489,39.294 11.144,39.294 11.76,39.91 11.76,44.992 13.529,46.571 38.024,46.571 38.024,40.379 39.389,39.014 51.906,39.014 54,41.109 54,48.006 52.781,49.225 -9.042,49.225 -11.273,46.995 -11.273,10.714
LV_SW1 on Top Layer "LV_SW1_L01_P000" (solid, remove dead copper, pour order 0): 15.088,10.084 25.011,10.084 25.011,-0.838 15.088,-0.838
LV_SW2 on Bottom Layer "LV_SW2_L06_P024" (solid, remove dead copper, pour order 24): 34.385,38.566 43.009,38.566 43.439,38.136 43.439,13.568 39.993,10.122 39.993,-0.838 30.074,-0.838 30.074,10.897 33.938,14.761 33.938,38.202
SGND on Bottom Layer "SGND_L06_P027" (solid, remove dead copper, pour order 27): 44.687,38.506 47.803,38.506 48.85,37.459 48.85,17.709 47.879,16.739 44.475,16.739 44.475,38.295
SGND on Bottom Layer "SGND_L06_P026" (solid, remove dead copper, pour order 26): 2.802,38.438 7.354,38.438 7.544,38.248 7.544,14.092 9.949,11.913 9.949,-0.838 0,-0.838 0,35.636
LV_SW1 on Bottom Layer "LV_SW1_L06_P025" (solid, remove dead copper, pour order 25): 8.592,38.195 8.861,38.465 17.818,38.465 17.983,38.3 17.983,14.732 18.974,13.741 21.793,13.741 25.011,10.524 25.011,-0.838 15.037,-0.838 15.012,-0.813 15.113,-0.712 15.113,10.008 8.592,15.361
48Vo+ on Bottom Layer "48VO+_L06_P023" (solid, remove dead copper, pour order 23): 19.286,38.465 32.573,38.465 32.943,38.095 32.943,15.418 32.409,14.884 19.595,14.884 19.011,15.468 19.011,38.19
SGND on MidLayer1 "SGND_L02_P029" (solid, remove dead copper, pour order 29): 0,35.636 2.802,38.438 47.871,38.438 48.85,37.459 48.85,15.305 46.829,13.284 11.989,13.284 9.949,11.244 9.949,-0.838 0,-0.838
SGND on MidLayer1 "SGND_L02_P028" (solid, remove dead copper, pour order 28): -1.067,10.338 -10.897,10.338 -11.252,10.693 -11.252,47.015 -9.042,49.225 52.654,49.225 53.289,48.59 53.289,40.665 51.918,39.294 37.973,39.294 37.668,39.599 37.668,43.718 37.012,44.374 34.925,44.374 32.537,46.761 15.926,46.761 13.538,44.374 12.243,44.374 11.76,43.891 11.76,40.615 10.439,39.294 2.489,39.294 -0.838,35.966 -0.838,10.566
SGND on MidLayer4 "SGND_L05_P046" (solid, remove dead copper, pour order 46): 0,35.636 2.794,38.43 7.671,38.43 8.28,37.821 8.28,13.468 9.949,11.8 9.949,-0.838 0,-0.838
48Vo+ on MidLayer4 "48VO+_L05_P033" (solid, remove dead copper, pour order 33): 19.011,38.19 19.286,38.465 32.573,38.465 32.943,38.095 32.943,21.252 35.704,18.491 50.876,18.491 55.033,14.334 55.033,-0.838 45.114,-0.838 45.114,10.334 43.993,11.455 24.079,11.455 18.926,16.609
SGND on MidLayer4 "SGND_L05_P030" (solid, remove dead copper, pour order 30): -10.897,10.338 -11.252,10.693 -11.252,47.015 -9.042,49.225 52.654,49.225 53.289,48.59 53.289,40.665 51.791,39.167 38.213,39.167 37.668,39.712 37.668,43.718 37.011,44.374 34.925,44.374 32.537,46.761 15.959,46.761 13.572,44.374 12.243,44.374 11.76,43.891 11.76,40.615 10.439,39.294 2.489,39.294 -0.838,35.966 -0.838,10.566 -1.067,10.338
LV_SW1 on MidLayer2 "LV_SW1_L03_P041" (solid, remove dead copper, pour order 41): 15.088,-0.838 15.088,10.11 8.592,15.275 8.592,37.305 8.917,37.63 16.599,37.63 17.216,37.013 17.216,18.318 25.011,11.244 25.011,-0.838
LV_SW2 on MidLayer2 "LV_SW2_L03_P040" (solid, remove dead copper, pour order 40): 34.087,-0.838 34.087,36.888 34.841,37.643 42.383,37.643 43.28,36.746 43.28,13.232 39.993,9.945 39.993,-0.838
48Vo+ on MidLayer3 "48VO+_L04_P038" (solid, remove dead copper, pour order 38): 18.926,38.104 19.286,38.465 32.573,38.465 32.943,38.095 32.943,21.252 35.704,18.491 50.876,18.491 55.033,14.334 55.033,-0.838 45.114,-0.838 45.114,10.334 43.993,11.455 24.079,11.455 18.926,16.609

## Other copper
Top Layer:
  region net 48Vo+: 20.218,37.949 31.601,37.949 32.573,36.977 32.573,17.536 30.505,15.469 22.479,15.469 19.303,18.318 19.303,37.194
  region net LV_SW2: 30.074,10.719 34.95,15.596 34.95,9.55 34.519,9.119 30.074,9.119
  region net SGND: 37.47,45.341 37.617,45.341 38.319,44.639 38.319,45.568
  region net 48Vo+: 45.114,10.334 55.033,10.334 55.033,-0.838 45.114,-0.838
  region net LV_SW2: 30.074,10.006 39.993,10.006 39.993,-0.838 30.074,-0.838
  region net SGND: 0.03,10.338 9.949,10.338 9.949,-0.838 0.03,-0.838
MidLayer2:
  region net LV_SW2: 34.599,15.193 38.229,15.193 40.011,13.411 40.005,13.405 40.005,-0.635 39.802,-0.838 30.074,-0.838 30.074,10.668
Bottom Layer:
  region net 48Vo+: 45.114,10.334 55.033,10.334 55.033,-0.838 45.114,-0.838
  region net LV_SW2: 30.074,10.006 39.993,10.006 39.993,-0.838 30.074,-0.838
  region net LV_SW1: 15.086,10.086 25.005,10.086 25.005,-0.838 15.086,-0.838 15.086,9.926

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Solder:
  region: 20.219,37.933 31.598,37.933 32.573,36.957 32.573,17.53 30.511,15.468 22.479,15.468 19.303,18.303 19.303,37.198
  region: 8.917,37.63 16.598,37.63 17.043,37.184 17.043,15.615 8.592,15.615 8.592,37.305
  region: 34.738,36.912 35.456,37.63 42.532,37.63 43.28,36.882 43.28,14.914 43.251,14.884 34.738,14.884
  region: 45.114,10.006 55.033,10.006 55.033,-0.838 45.114,-0.838
  region: 30.074,10.006 39.993,10.006 39.993,-0.838 30.074,-0.838
  region: 15.086,10.006 25.011,10.006 25.011,-0.838 15.086,-0.838
  region: 0.03,10.02 9.949,10.02 9.949,-0.838 0.03,-0.838
Bottom Solder:
  region: 45.114,10.006 55.033,10.006 55.033,-0.838 45.114,-0.838
  region: 30.074,10.006 39.993,10.006 39.993,-0.838 30.074,-0.838
  region: 15.086,10.006 25.011,10.006 25.011,-0.838 15.088,-0.838
  region: 0.03,10.02 9.949,10.02 9.949,-0.838 0.03,-0.838
Mechanical 1:
  lines w0.025: 40.056,10.008 45.034,10.008 45.034,-0.838 55.067,-0.838 55.067,10.007 55.068,10.007 55.728,10.006 55.651,49.428 -11.684,49.428 -11.684,10.008 0,10.008 0,-0.838 10.008,-0.838 10.008,10.008 15.011,10.008 15.012,-0.838 25.044,-0.838 25.044,10.008 30.048,10.008 30.048,-0.838 40.056,-0.838 40.056,10.008